# Keil uVision project Automotive_Smart_Safety_RTOS_Embedded_System.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Automotive_Smart_Safety_RTOS_Embedded_System
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=1
  c define: PART_TM4C123GH6PM
  c include: ..\Automotive_Smart_Safety_RTOS_Embedded_System;.\Drivers\driverlib;.\Drivers\inc;C:\TivaWare_C_Series-2.2.0.295
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c safety_tasks.c lcd.c drivers.c safety_tasks.h lcd.h drivers.h
  group Drivers
    ./Drivers/driverlib/rvmdk/: driverlib.lib
software components: RTOS:Config 11.2.0, RTOS:Core 11.2.0, RTOS:Event Groups 11.2.0, RTOS:Heap 11.2.0, RTOS:Timers 11.2.0, CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:FreeRTOS 11.2.0, Device:Startup 1.0.1
